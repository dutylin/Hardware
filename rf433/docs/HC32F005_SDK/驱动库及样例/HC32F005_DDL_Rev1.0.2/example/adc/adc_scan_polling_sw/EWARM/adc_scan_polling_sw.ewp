# IAR project adc_scan_polling_sw.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: HC32F005C6UA HDSC HC32F005C6UA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: adc_scan_polling_sw.srec
  ILINK.IlinkOutputFile: adc_scan_polling_sw.out
  ILINK.IlinkIcfFile: HC32F005.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\utility
  group common
    ../../../../driver/src/: ddl.c interrupts_hc32f005.c
    ./: startup_hc32f005.s
    ../../../../mcu/common/: system_hc32f005.c
  group driver
    ../../../../driver/src/: adc.c clk.c gpio.c
  group README
    ../: Readme.txt
  group source
    ../source/: main.c

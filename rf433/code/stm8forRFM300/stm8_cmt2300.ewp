# IAR project stm8_cmt2300.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K4 STM8S105K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: STM8S_StdPeriph_Driver\inc; 
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: stm8sforchuangwei.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group (top)
    STM8S_StdPeriph_Driver/src/: CMT2300drive.c spi.c
    ./: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
  group STM8S_StdPeriph_Driver
    STM8S_StdPeriph_Driver/src/: delay.c stm8s_clk.c stm8s_gpio.c stm8s_tim4.c

# Keil uVision project ADC.uvproj, settings and files
target ADC (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ADC +hex
  c flags: Optim=4 OneElfS=1
  c include: ..\..\library\inc;..\..\library\src;..\uvsion
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Code
    ./: STM32F10x.s
  group Source Code
    ./: main.c stm32f10x_it.c
  group libary
    E:/Boards/M3/okstm32v100/示例程序/common/: STM32F10xR.LIB

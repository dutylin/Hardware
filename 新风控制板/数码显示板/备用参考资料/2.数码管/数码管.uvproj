# Keil uVision project 数码管.uvproj, settings and files
target GPIO (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: release +hex
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup Code
    ./: STM32F10x.s
  group Source
    ./: main.c
  group Interrupts
    ./: stm32f10x_it.c
  group Library
    E:/Boards/M3/okstm32v100/示例程序/common/: STM32F10xR.lib
  group Documentation
    ./: readme.txt

# Keil uVision project PWR.uvproj, settings and files
target PWR_Test (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: release +hex
  c flags: Optim=1 OneElfS=1
  c include: .\
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Code
    ./: STM32F10x.s
  group Source
    ./: main.c
  group Interrupts
    ./: stm32f10x_it.c
  group Library
    E:/Boards/M3/okstm32v100/示例程序/common/: STM32F10xR.lib
target STM32F10x Debug (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: debug
  c flags: Optim=1
  c include: .\
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000

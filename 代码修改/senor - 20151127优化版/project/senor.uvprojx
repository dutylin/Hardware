# Keil uVision project senor.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: senor +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32L1XX_MD,Liceng
  c include: ..\..\1213\sjzj\oled+usart\user;..\APP;..\BSP;..\CMSIS\Include;..\CMSIS\Device\ST\STM32L1xx\Source;..\source\inc;..\source\src
  asm define: USE_STDPERIPH_DRIVER STM32L1XX_MD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../APP/: main.c user.c stm32l1xx_it.c
    ../../1213/sjzj/oled+usart/user/: OLED.c
  group startup
    ./: startup_stm32l1xx_md.s
  group cmsis
    ../CMSIS/Include/: core_cm3.h
    ../CMSIS/Device/ST/STM32L1xx/Include/: stm32l1xx.h system_stm32l1xx.h
    ../CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group bsp
    ../BSP/: adc.c CC1110.c other.c spi.c flash.c infrared.c rtc.c SST25VF016B_Operation.c
  group lib
    ../source/src/: stm32l1xx_rtc.c stm32l1xx_spi.c misc.c stm32l1xx_adc.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_dma.c stm32l1xx_pwr.c stm32l1xx_usart.c stm32l1xx_tim.c stm32l1xx_flash.c stm32l1xx_syscfg.c stm32l1xx_dbgmcu.c

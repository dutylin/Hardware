# Keil uVision project ss.uvprojx, settings and files
target ss (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ss +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L152xB
  c include: ../Inc;          ../Drivers/STM32L1xx_HAL_Driver/Inc;          ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;          ../Drivers/CMSIS/Device/ST/STM32L1xx/Include;          ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ss\ss.sct
  group Application/User
    ../Src/: SST25VF016B_Operation.c main.c stm32l1xx_it.c stm32l1xx_hal_msp.c rtc.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c
  group Drivers/CMSIS
    ./: startup_stm32l152xb.s
    ../Src/: system_stm32l1xx.c
software components: CMSIS:CORE 4.3.0
